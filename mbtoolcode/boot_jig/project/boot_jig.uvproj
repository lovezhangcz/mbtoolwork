# Keil uVision project boot_jig.uvproj, settings and files
target boot_jig (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x80027FF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot_jig +hex
  AfterMake: fromelf.exe --bin --output .\obj\boot_jig.bin .\obj\boot_jig.axf
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,MODEM_KS_JIG
  c misc: --c99
  c include: ..\src;..\inc;..\system;..\..\fw_lib\inc;..\..\fw_lib\CMSIS\CM3\CoreSupport
  asm include: ..\system
  memory RVCT4: ROM 0x8000000 size 0xc800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../system/: startup_stm32f10x_hd.s
  group CMSIS
    ../../fw_lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../system/: system_stm32f10x.c
  group fw_lib
    ../../fw_lib/: fw_lib_hd.lib
  group boot
    ../src/: main.c dis_update.c aes.c flash_port.c GD32_ADD.c stm32f10x_bkp.c stm32f10x_pwr.c usartset_u4.c
