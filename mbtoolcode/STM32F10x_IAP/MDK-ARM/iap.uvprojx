# Keil uVision project iap.uvprojx, settings and files
target IAP_KS_FX1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iap_FX1big +hex
  AfterMake: fromelf.exe --bin -o ./iap_FX1big.bin ./Objects/iap_FX1big.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,MODEM_KS_FX1
  c include: ..\inc;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../src/: aes.c flash_port.c main.c stm32f10x_bkp.c stm32f10x_pwr.c dis_update.c GD32_ADD.c usartset_u1.c bbcpro.h bbcpro_bb.c usartset_u3.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
